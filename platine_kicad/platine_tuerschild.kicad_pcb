# Repository AMG-Friesoythe/dtuerschild_hardware

## KiCad design platine_kicad/platine_tuerschild.kicad_pcb

Board: 2 copper layers, 90.0 x 50.0 mm, 13 parts (0 on the bottom side), 17 nets.

Parts:
Batt1: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
C1: CP; CP_Radial_D6.3mm_P2.50mm
E-Ink1: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
ESP1: ESP32-WROOM-32
IC1: SGM809-TXN3L; SOT-23
J1: Jump; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J4: Dev; PinHeader_1x07_P2.54mm_Vertical
LDO1: MCP1700-3002E_SOT-23; SOT-23
R1, R3, R4: R_Small; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
unnamed: Batt1.1, C1.2, E-Ink1.7, ESP1.1 (GND), ESP1.15 (GND), ESP1.38 (GND), ESP1.39 (GND), IC1.1 (GND), J1.1, J3.1, J3.2, J4.2, LDO1.1 (GND), R1.2, R3.2
unnamed: Batt1.2, IC1.3 (VCC), LDO1.2 (VI), R4.1
unnamed: C1.1, E-Ink1.8, ESP1.2 (VDD), J1.2, J3.3, J3.4, J4.1, LDO1.3 (VO)
unnamed: E-Ink1.1, ESP1.26 (IO4)
unnamed: E-Ink1.2, ESP1.33 (IO21)
unnamed: E-Ink1.3, ESP1.36 (IO22)
unnamed: E-Ink1.4, ESP1.29 (IO5)
unnamed: E-Ink1.6, ESP1.37 (IO23)
unnamed: ESP1.3 (EN), J4.6, R1.1
unnamed: ESP1.12 (IO27), R3.1, R4.2
unnamed: ESP1.23 (IO15), J2.3
unnamed: ESP1.25 (IO0), J4.5
unnamed: ESP1.27 (IO16), J2.2
unnamed: ESP1.28 (IO17), J2.1
unnamed: ESP1.34 (RXD0/IO3), J4.3
unnamed: ESP1.35 (TXD0/IO1), J4.4
unnamed: IC1.2 (~RESET/RESET), J4.7

## Commit log

2023-01-14 Add files via upload
    added freecad models for the casing
2023-03-02 Platine v2
